# Keil uVision project Project.uvprojx, settings and files
target STM3210B-EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD, USE_STM3210B_EVAL,__CC_ARM
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\App\Bsp\include;..\..\..\App\include;..\..\..\App\Task;..\..\..\App\Object\MbSlave;..\..\..\App\Task\MbTask;..\..\..\App\Task\IoTask;..\..\..\App\Task\CycTask;..\..\..\App\Bsp\LcdBsp;..\..\..\App\Task\Instrmnt;..\..\..\App\Task\OlcdTask;..\..\..\App\Task\MotionTask;..\..\..\App\Task\DiKeyTask;..\..\..\App\Object\LCD;..\..\..\App\Bsp\FlashBsp;..\..\..\App\Task\SysLedTask;..\..\..\App\Bsp\LedBsp;..\..\..\App\Task\MbToVarTask;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../Utilities/STM32_EVAL/Common/: stm32_eval_spi_sd.c stm32_eval_i2c_ee.c stm32_eval_i2c_tsensor.c stm32_eval_sdio_sd.c stm32_eval_spi_flash.c
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval_lcd.c
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c stm3210e_eval_fsmc_sram.c stm3210e_eval_fsmc_nand.c stm3210e_eval_fsmc_nor.c
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval_lcd.c stm3210c_eval_ioe.c
    ../../../Utilities/STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c stm32100b_eval_cec.c
    ../../../Utilities/STM32_EVAL/STM32100E_EVAL/: stm32100e_eval_lcd.c stm32100e_eval_ioe.c stm32100e_eval_cec.c stm32100e_eval_fsmc_onenand.c stm32100e_eval_fsmc_sram.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group App
    ../../../App/Task/CycTask/: CycTask.c
    ../../../App/Task/SysLedTask/: DisplayTask.c
    ../../../App/Task/IoTask/: TouchSwitchTask.c
  group Bsp
    ../../../App/Bsp/TaskBsp/: Bsp_OsTask.c
    ../../../App/Bsp/GpioBsp/: Bsp_Gpio.c
    ../../../App/Bsp/KeyBsp/: Bsp_Key.c
    ../../../App/Bsp/UartBsp/: Bsp_Uart.c Bsp_PWM.c
    ../../../App/Bsp/FlashBsp/: Bsp_Flash.c
    ./: BSP_595.c BSP_AD9833.c Bsp_ADC.c
  group Doc
    ./: readme.txt
software components: CMSIS:CORE 4.3.0
